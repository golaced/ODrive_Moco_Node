# Keil uVision project F407_FC.uvprojx, settings and files
target OLD-X FC 2.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6LangP=3 v6Lto=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\DSP_LIB\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\Libraries\CMSIS\Include;.\MAVLINK;.\MAVLINK\minimal;.\estimator_sr;.\quadruped_src;.\system_src;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_HOST_Library\Core\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_APP;..\HARDWARE\USB\STM32_USB_Device_Library\Class\cdc\inc;.\USB\STM32_USB_Device_Library\Class\cdc\inc;.\DSP_LIB\Include;.\DSP_LIB\;.\quadruped_src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./applications/: main.c stm32f4xx_it.c
    ./system_src/: delay.c sys.c
    ../../Quadruped Moco8 BLDC/drivers/: time.c
    ./: Debug_Record
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rng.c stm32f4xx_can.c stm32f4xx_iwdg.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Communication
    ./drivers/: can.c
    ./applications/: my_math.c mymath.c fliter.c
software components: CMSIS:CORE 5.2.0
